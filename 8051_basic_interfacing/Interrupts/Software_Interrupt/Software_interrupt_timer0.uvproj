# Keil uVision project Software_interrupt_timer0.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LV51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Software_interrupt_timer0 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../: Software_Interrupt_timer0.c
